# IAR project Project.ewp, settings and files
configuration STM8S003 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; Application; c:\_forDevelop\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccExtraOptions: --discard_unused_publics
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8S005 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S005C6 STM8S005C6
  ICCSTM8.CCDefines: STM8S005
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc
configuration STM8S007 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S007C8 STM8S007C8
  ICCSTM8.CCDefines: STM8S007
  ICCSTM8.CCIncludePath2: as above
  group Application
    Application/: main.c pwm_control.c stm8s_it.c
  group SPL
    ../../../_forDevelop/STM8S_StdPeriph_Lib/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c

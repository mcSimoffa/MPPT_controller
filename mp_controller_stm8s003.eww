<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>Project.ewp</path>
    </project>
    <batchBuild />
</workspace>
